Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-10-24T16:24:00
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 24 16:24:00 2022 * Host: DSBIRNE-RO-LE * Database: C:\Users\DSbirne\AppData\Local\Temp\4a2a7b7e-aaa6-4ace-aaff-4e93a8de6c4c\612a5807-35e1-4ce5-b80d-f984acae3620\ifc * Database version: 5507 * Database creation date: Mon Oct 24 16:23:59 2022 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Oct 24 16:24:00 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 24 16:24:00 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Floor Level, F00
LongName: F00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Pset_BuildingStoreyCommon - Reference: Floor Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: F00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level

# IfcDistributionPort, Port_5018778
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcOutlet: 2CKA006512A0334, E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA006512A0334_NL-NL:2CKA006512A0334:5018783
In: F00
Type - PredefinedType: POWEROUTLET; Material: Color RGB 150-150-150
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Depth: 10 mm; Height: 71 mm; Rounding Radius: 4 mm; Width: 71 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM
Type - Identity Data - Article Code: Default; Article Description: Dimmer 250va led w/va inb; Base Family Version: 20221003; Category: EL_SYMBOL_ARTICLE; Content Supplier URL: www.MEPcontent.com; Custom: yes; Description: Dimmer 250va led w/va inb; EMCS Version: 4.0; ETIM Article Class: EC000025; Family Version: 11.17; GLN: 8712507900012; GTIN: 4011395212677; Manufacturer: ABB BUSCH-JAEGER; Manufacturer Art. No.: 2CKA006512A0334; Manufacturer Type: 6523 U-102; Manufacturer URL: https://www.abbconnect.nl/artlink.aspx?id=4011395212677&LanguageCode=NL&Country=NL; MEPcontent Class: ELECTRICAL_FIXTURES; OmniClass Number: 23.80.50.11; OmniClass Title: Switches and Receptacles; Revit Version: 2020; Type Name: 2CKA006512A0334; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Data Devices; Family Name: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA006512A0334_NL-NL
Type - Pset_EnvironmentalImpactIndicators - Reference: 2CKA006512A0334
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB BUSCH-JAEGER
Type - Pset_OutletTypeCommon - Reference: 2CKA006512A0334
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Moves With Nearby Elements: no; Position Condition: 0
Dimensions - Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Area: 0.00701291 m2; Volume: 0.0000522726 m3
Identity Data - Copyright: © Trimble Europe BV; Mark: 3; VERSION: 220800
Other - Family: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA006512A0334_NL-NL: 2CKA006512A0334; Family and Type: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA006512A0334_NL-NL: 2CKA006512A0334; Type: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA006512A0334_NL-NL: 2CKA006512A0334; Type Id: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA006512A0334_NL-NL: 2CKA006512A0334
Phasing - Phase Created: 4. Plan over 10 years

# IfcOutlet: Busch-balance SI_2CKA001725A1555_hor_1, E_Frame_Dimmer Rotary_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_NL-NL:Busch-balance SI_2CKA001725A1555_hor_1:5018778
In: F00
Type - PredefinedType: POWEROUTLET; Material: Color RAL 9010
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 11 mm; Frame Thickness: 15 mm; Gang Height: 56 mm; Gang Width: 56 mm; Height: 81 mm; Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Rounding Gang: 1 mm; Rounding Radius: 2 mm; Width: 81 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM; Frame Type: Alpinwit; Material: Color RAL 9010; Number of Gangs: 1
Type - Identity Data - Article Code: Default; Article Description: Afdekraam 1v SI-B; Article Type: 1-gang frame; Base Family Version: 20221003; Category: EL_SYMBOL_ARTICLE; Content Supplier URL: www.MEPcontent.com; Custom: no; Description: Afdekraam 1v SI-B; EMCS Version: 4.0; ETIM Article Class: EC000007; Family Version: 11.17; GLN: 8712507900012; GTIN: 4011395191460; Manufacturer: ABB BUSCH-JAEGER; Manufacturer Art. No.: 2CKA001725A1555; Manufacturer Type: 1721-914; Manufacturer URL: https://www.abbconnect.nl/artlink.aspx?id=4011395191460&LanguageCode=NL&Country=NL; MEPcontent Class: ELECTRICAL_FIXTURES; Model: 1-gang frame; OmniClass Number: 23.80.50.11; OmniClass Title: Switches and Receptacles; Product Line: Busch-balance SI; Revit Version: 2020; Type Name: Busch-balance SI_2CKA001725A1555_hor_1; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Data Devices; Family Name: E_Frame_Dimmer Rotary_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_NL-NL
Type - Pset_EnvironmentalImpactIndicators - Reference: Busch-balance SI_2CKA001725A1555_hor_1
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB BUSCH-JAEGER
Type - Pset_OutletTypeCommon - Reference: Busch-balance SI_2CKA001725A1555_hor_1
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Elevation from Level: 0 mm
Dimensions - Area: 0.0124699 m2; Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Volume: 0.0000323103 m3
Electrical - Loads - Power: 0 W
Identity Data - Copyright: © Trimble Europe BV; Mark: 2; VERSION: 220800
Other - Family: E_Frame_Dimmer Rotary_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_NL-NL: Busch-balance SI_2CKA001725A1555_hor_1; Family and Type: E_Frame_Dimmer Rotary_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_NL-NL: Busch-balance SI_2CKA001725A1555_hor_1; Gang 3: 0 mm; Gang Reference Line: 56 mm; Interior Width: 28 mm; Number of Representation Line: 2; Type: E_Frame_Dimmer Rotary_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_NL-NL: Busch-balance SI_2CKA001725A1555_hor_1; Type Id: E_Frame_Dimmer Rotary_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_NL-NL: Busch-balance SI_2CKA001725A1555_hor_1
Phasing - Phase Created: 4. Plan over 10 years

# IfcSwitchingDevice: Busch-balance SI_1 Pole Dimmer_2CKA006599A3017, E_Switch_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA006599A3017_NL-NL:Busch-balance SI_1 Pole Dimmer_2CKA006599A3017:5018782
In: F00
Type - PredefinedType: CONTACTOR; Material: Color RAL 9010
Type - Constraints - Default Elevation: 1050 mm
Type - Dimensions - Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Depth: 11 mm; Height: 55 mm; Rounding Radius: 1 mm; Width: 55 mm
Type - Electrical - Material: Color RAL 9010; App ID: EL_MODELPARTSYSTEM; Insert Type: Alpinwit
Type - Identity Data - Custom: no; Article Code: Default; Article Description: Cpl + knop v draaidimmer SI-B; Base Family Version: 20221003; Category: EL_SINGLEPOLESWITCH; Content Supplier URL: www.MEPcontent.com; Description: Cpl + knop v draaidimmer SI-B; EMCS Version: 4.0; ETIM Article Class: EC000011; Family Version: 11.21; GLN: 8712507900012; GTIN: 4011395190678; Manufacturer: ABB BUSCH-JAEGER; Manufacturer Art. No.: 2CKA006599A3017; Manufacturer Type: 2115-914; Manufacturer URL: https://www.abbconnect.nl/artlink.aspx?id=4011395190678&LanguageCode=NL&Country=NL; MEPcontent Class: LIGHTING_DEVICES; OmniClass Number: 23.80.00.00; OmniClass Title: Electric Power and Lighting; Product Line: Busch-balance SI; Revit Version: 2020; Type Name: Busch-balance SI_1 Pole Dimmer_2CKA006599A3017; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Lighting Devices; Family Name: E_Switch_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA006599A3017_NL-NL
Type - Visibility - Number Of Representation: 6
Type - Pset_EnvironmentalImpactIndicators - Reference: Busch-balance SI_1 Pole Dimmer_2CKA006599A3017
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB BUSCH-JAEGER
Type - Pset_SwitchingDeviceTypeCommon - Reference: Busch-balance SI_1 Pole Dimmer_2CKA006599A3017
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Annotation: 14; Moves With Nearby Elements: no; Position Condition: 0
Dimensions - Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Area: 0.00681951 m2; Volume: 0.0000478606 m3
Identity Data - Copyright: © Trimble Europe BV; Mark: 1; VERSION: 220800
Other - Annotation SwitchDimmerOnePole: yes; Family: E_Switch_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA006599A3017_NL-NL: Busch-balance SI_1 Pole Dimmer_2CKA006599A3017; Family and Type: E_Switch_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA006599A3017_NL-NL: Busch-balance SI_1 Pole Dimmer_2CKA006599A3017; Type: E_Switch_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA006599A3017_NL-NL: Busch-balance SI_1 Pole Dimmer_2CKA006599A3017; Type Id: E_Switch_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA006599A3017_NL-NL: Busch-balance SI_1 Pole Dimmer_2CKA006599A3017
Phasing - Phase Created: 4. Plan over 10 years
